# Keil uVision project key.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7321 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: key +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user
  group Source Group 1
    ./: STARTUP.A51
    ../user/: main.c
    ../TimeOut/: TimeOut.c
    ../bsp/: key.c key_port.c
